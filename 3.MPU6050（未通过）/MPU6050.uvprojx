# Keil uVision project MPU6050.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Drive\TIME;.\Drive\USART;.\Drive\I2C;.\Drive\CONTROL;.\Drive\DMP;.\Drive\filter;.\Drive\sys;.\Drive\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
    ./FWLib/src/: misc.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group APP
    ./Drive/TIME/: delay.c timer.c
    ./Drive/USART/: usart.c
    ./Drive/I2C/: i2c.c
    ./Drive/CONTROL/: control.c
    ./Drive/filter/: filter.c
    ./Drive/MPU6050/: MPU6050.c
    ./Drive/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Drive/sys/: sys.c
software components: CMSIS:CORE 4.3.0
